# IAR project kp02.ewp, settings and files
configuration KP02_DEVICE_2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARM_CM4; USE_STDPERIPH_DRIVER; STM32F40_41xxx; HAVE_CONFIG_H; SD_SPI_MODE; USE_FULL_ASSERT; DEVICE_2; TFT; STENDBUY_NOT_USE; SCREEN_NOT_ROTATE; USE_ADS1292R; DISPLAY_GPIO; BUFFERED_TRANSFER; LCD_TRACE
  ICCARM.CCIncludePath2: $PROJ_DIR$; FatFs\; FreeRTOS\Source\include\; FreeRTOS\Source\portable\IAR\ARM_CM3\; Libraries\CMSIS\CM4\CoreSupport\; Libraries\CMSIS\CM4\DeviceSupport\STM32F4xx\; Libraries\STM32F4xx_StdPeriph_Driver\inc\; Libraries\STM32F10x_Speex_Lib\include\speex\; Libraries\STM32F10x_Speex_Lib\include\; Libraries\STM32F10x_Speex_Lib\libspeex\; Libraries\STM32F10x_Speex_Lib\STM32\include\speex\; Libraries\STM32F10x_Speex_Lib\STM32\include\; Libraries\STM32F10x_Speex_Lib\STM32\; Libraries\STM32F10x_Speex_Lib\STM32\libspeex\; Libraries\STM32F10x_Speex_Lib\STM32\libspeex\iar\; Fonts
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; FreeRTOS\Source\include; FreeRTOS\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: kp02.bin
  ILINK.IlinkOutputFile: kp02.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration KP02_DEVICE_2_BOOT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_ARM_CM4; USE_STDPERIPH_DRIVER; STM32F40_41xxx; HAVE_CONFIG_H; SD_SPI_MODE; BOOTLOADER; IAP_CFG; DEVICE_2; TFT; DISPLAY_GPIO; ECGMCUDONTFWUPDATE
  ICCARM.CCIncludePath2: $PROJ_DIR$; FatFs\; FreeRTOS\Source\include\; FreeRTOS\Source\portable\IAR\ARM_CM3\; Libraries\CMSIS\CM4\CoreSupport; Libraries\CMSIS\CM4\DeviceSupport\STM32F4xx; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\STM32F10x_Speex_Lib\include\speex\; Libraries\STM32F10x_Speex_Lib\include\; Libraries\STM32F10x_Speex_Lib\libspeex\; Libraries\STM32F10x_Speex_Lib\STM32\include\speex\; Libraries\STM32F10x_Speex_Lib\STM32\include\; Libraries\STM32F10x_Speex_Lib\STM32\; Libraries\STM32F10x_Speex_Lib\STM32\libspeex\; Libraries\STM32F10x_Speex_Lib\STM32\libspeex\iar\; Fonts
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: bootloader.icf
  group _Application
    ./: FreeRTOSConfig.h main.cpp stm32_it.c system_stm32f4xx.c TAppProcessor.cpp TDevice.cpp TDSP.cpp THardware.cpp TInterpreter.cpp TNandWrite.cpp TPoolingNand.cpp TSound.cpp Utilities.cpp
  group _Application/AELAB
    ./: StnFont.cpp TLcdTrace.cpp
  group _Application/Audio
    ./: TAudio.cpp
  group _Application/Bluetooth
    ./: TFrame.cpp TLMX9838.cpp
  group _Application/Bootloader
    ./: common.c download.c flash_if.c IAP.cpp ymodem.c
  group _Application/ECG
    ./: TADS1292.cpp TADS1298.cpp TEcgProcessor.cpp TRespProcessor.cpp
  group _Application/ECGMCU bin
    ./: EcgMcu.h
  group _Application/Flash
    ./: eeprom.c TFlash.cpp
  group _Application/Lcd
    ./: TFont.cpp TGuiObjectsV2.cpp TLcd.cpp
  group _Application/RTC
    ./: TRtc.cpp
  group _Application/SD card
    FatFs/: diskio.h ff.c ff.h ffconf.h mmc.c sd_sdio.c sd_spi.c
    ./: TMmc.cpp TSDProcessor.cpp TSDProcessor.h
  group _Application/SPI_SRAM
    ./: TSpiSram.cpp
  group CMSIS
    Libraries/CMSIS/CM4/DeviceSupport/STM32F4xx/: startup_stm32f40_41xxx.s
  group FreeRTOS/include
    FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
    FreeRTOS/Source/portable/IAR/ARM_CM3/: port.h portmacro.h
  group FreeRTOS/source
    FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    FreeRTOS/Source/portable/MemMang/: heap_2.c
    FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group STM32F4xx_StdPeriph_Driver/include
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fmc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group STM32F4xx_StdPeriph_Driver/source
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
