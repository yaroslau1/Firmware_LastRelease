<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\Firmware_Working\_7.0.92_Resp_Test\ECGMCU\kp02.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\Firmware_Working\_7.0.92_Resp_Test\MainMCU\kp02.ewp</path>
  </project>
  <batchBuild/>
</workspace>


