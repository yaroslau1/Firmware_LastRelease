# IAR project kp02.ewp, settings and files
configuration ECG_MCU (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARM_CM0; USE_STDPERIPH_DRIVER; STM32F030; HAVE_CONFIG_H; USE_FULL_ASSERT; DEVICE_2; USE_ADS1292R; DISPLAY_GPIO
  ICCARM.CCIncludePath2: $PROJ_DIR$; Libraries\CMSIS\CM0\CoreSupport; Libraries\CMSIS\CM0\DeviceSupport\STM32F0xx; Libraries\STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; FreeRTOS\Source\include; FreeRTOS\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: ecgmcu.bin
  ILINK.IlinkOutputFile: kp02.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ECG_MCU_BOOT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_ARM_CM0; USE_STDPERIPH_DRIVER; STM32F030; HAVE_CONFIG_H; BOOTLOADER
  OBJCOPY.OOCOutputFile: kp02.bin
  ILINK.IlinkIcfFile: bootloader.icf
  group _Application
    ./: flash_if.c main.cpp stm32_it.c system_stm32f0xx.c TAxel.cpp TInterpreter.cpp TLed.cpp TPowerManagement.cpp TRtc.cpp
  group _Application/ECG
    ./: TECG.cpp
  group _Application/IAP
    ./: IAP.cpp
  group _Application/SRAM
    ./: TSpiSram.cpp
  group CMSIS
    Libraries/CMSIS/CM0/DeviceSupport/STM32F0xx/: startup_stm32f030.s
  group STM32F0xx_StdPeriph_Driver/include
    Libraries/STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group STM32F0xx_StdPeriph_Driver/source
    Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
